# Keil uVision project bootloader_Boot.uvprojx, settings and files
target bootloader_Boot (6220000::V6.22::ARMCLANG)
  device: STM32H7S7L8HxH STMicroelectronics
  pack: Keil.STM32H7RSxx_DFP.1.0.1
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x24000000-0x24071BFF) IROM(0x8000000-0x800FFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: bootloader_Boot +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H7S7xx
  c include: ../../Boot/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc;../../Drivers/STM32H7RSxx_HAL_Driver/Inc/Legacy;../../Middlewares/ST/STM32_ExtMem_Manager;../../Middlewares/ST/STM32_ExtMem_Manager/boot;../../Middlewares/ST/STM32_ExtMem_Manager/sal;../../Middlewares/ST/STM32_ExtMem_Manager/nor_sfdp;../../Middlewares/ST/STM32_ExtMem_Manager/psram;../../Middlewares/ST/STM32_ExtMem_Manager/sdcard;../../Middlewares/ST/STM32_ExtMem_Manager/user;../../Drivers/CMSIS/Device/ST/STM32H7RSxx/Include;../../Drivers/CMSIS/Include;../../third_party/aps256xx;../../third_party/w35t51nwtbie
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x24000000 size 0x71c00
  scatter file: stm32h7s7xx_flash.sct
  link misc: --diag_suppress L6312,L6314
  group Application/MDK-ARM
    ../: startup_stm32h7s7xx.s
  group Application/User/Boot
    ../../Boot/Src/: main.c gpio.c adc.c dts.c flash.c memorymap.c sbs.c usart.c xspi.c stm32h7rsxx_it.c stm32h7rsxx_hal_msp.c
  group Drivers/CMSIS
    ../../Boot/Src/: system_stm32h7rsxx.c
  group Third-Party/aps256xx
    ../../third_party/aps256xx/: aps256xx.c
  group Drivers/STM32H7RSxx_HAL_Driver
    ../../Drivers/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_exti.c stm32h7rsxx_hal_dts.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_xspi.c
  group Third-Party/w35t51nwtbie
    ../../third_party/w35t51nwtbie/: w35t51nwtbie.c
software components: CMSIS:CORE 5.6.0
